# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F427
  c include: ..\App;..\App\app_cmd;..\Bsp\gd32f4;..\Bsp\gd32f4\Include;..\Bsp\gd32f4\Source;..\Startup;..\Startup\Include;..\Startup\Source;..\Components\circular_buffer\src;..\Components\circular_buffer\port;..\Components\lettershell\src;..\Components\lettershell;..\Components\lettershell\port;..\HAL\port\gd32f4xx;..\HAL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../App/: app_cmd.c main.c
  group Components/cir_buf
    ../Components/circular_buffer/src/: circular_buffer.c
    ../Components/circular_buffer/port/: port.c
  group Components/lettershell
    ../Components/lettershell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Components/lettershell/port/: shell_port.c
  group Startup
    ../Startup/: gd32f4xx_it.c startup_gd32f407_427.s system_gd32f4xx.c systick.c
  group Bsp
    ../Bsp/gd32f4/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Hal
    ../HAL/: hal_dma.c hal_gpio.c hal_i2c.c hal_uart.c
  group Hal_port
    ../HAL/port/gd32f4xx/: hal_dma_port.c hal_gpio_port.c hal_i2c_port.c hal_port.c hal_uart_port.c
